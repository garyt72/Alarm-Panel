# Repository garyt72/Alarm-Panel

File README.md:

# Alarm Panel

ESPHome-based ESP32 alarm controller replacement.

## Repository Layout

```
.
|-- hardware/
|   `-- alarm-panel/
|       |-- Alarm Panel.kicad_pro
|       |-- fp-lib-table
|       |-- sym-lib-table
|       |-- Alarm Panel.kicad_sch
|       |-- Alarm Panel.kicad_pcb
|       |-- footprints/
|       |   |-- AlarmPanel_THT.pretty/
|       |   `-- README.md
|       `-- symbols/
|   `-- enclosure/
|       `-- 3d-printing/
|           `-- legacy/
|-- tools/
|   `-- pcb/
|       |-- project_paths.py
|       `-- *.py
|-- docs/
|   `-- pcb/
|       |-- images/
|       |-- pinout-and-ethernet.md
|       |-- pcb-design-brief.md
|       |-- pcb-first-pass-layout.md
|       |-- pcb-schematic-block-plan.md
|       `-- pcb-top-down-mockup.md
|-- esphome/
|   |-- alarm-panel-oled.yaml
|   `-- secrets.yaml
`-- .gitignore
```

## Getting Started

1. The tracked [esphome/secrets.yaml](esphome/secrets.yaml) contains placeholder values; replace them locally before connecting the device to real networks or users.
2. Adjust [esphome/alarm-panel-oled.yaml](esphome/alarm-panel-oled.yaml) for your node name and device-specific components.
3. Compile or upload with ESPHome, for example:

	```bash
	esphome run esphome/alarm-panel-oled.yaml
	```

## Notes

- `esphome/` holds the top-level ESPHome node configuration and its secrets file.
- `hardware/alarm-panel/` holds the KiCad project and its project-local footprint and symbol libraries.
- `tools/pcb/` holds scripts that generate, inspect, or update the KiCad design.
- `docs/pcb/` holds hardware notes, pin maps, validation checklists, and reference images.
- `hardware/enclosure/3d-printing/` holds printable enclosure models; historical versions are kept under `legacy/`.
- `esphome/secrets.yaml` is a tracked placeholder template. Never replace its placeholders with real credentials in a commit.
- Root-level `secrets.yaml` files are ignored by git for local ESPHome configurations.

## Hardware Notes

The current config is based on the ideaspark ESP32 0.96in OLED board used for the alarm-panel-oled device. It uses an SSD1306 128x64 OLED on I2C GPIO21/GPIO22 and keeps the alarm-zone inputs and outputs mapped around that layout.

If you add the W5500 Ethernet module, the four relocated zone inputs must use external pull-up resistors to 3.3V because GPIO34, GPIO35, GPIO36, and GPIO39 do not provide internal pull-ups. A 10 kΩ resistor is the normal starting point, with 4.7 kΩ recommended for longer or noisier runs.

See [docs/pcb/pinout-and-ethernet.md](docs/pcb/pinout-and-ethernet.md) for the existing pin-out, the pin-by-pin W5500 migration plan, the updated pin-out, and the resistor guidance.

For PCB work based on the perfboard prototype photos, see [docs/pcb/pcb-design-brief.md](docs/pcb/pcb-design-brief.md).

For a human-readable top-down board mockup, see [docs/pcb/pcb-top-down-mockup.md](docs/pcb/pcb-top-down-mockup.md).

For the schematic-to-footprint handoff plan, see [docs/pcb/pcb-schematic-block-plan.md](docs/pcb/pcb-schematic-block-plan.md).

For the current outstanding design, routing, validation, and JLCPCB release items, see [docs/pcb/pcb-completion-checklist.md](docs/pcb/pcb-completion-checklist.md).

Open [hardware/alarm-panel/Alarm Panel.kicad_pro](hardware/alarm-panel/Alarm%20Panel.kicad_pro) in KiCad to load the schematic, board, and project-local footprint library together. The schematic is at [hardware/alarm-panel/Alarm Panel.kicad_sch](hardware/alarm-panel/Alarm%20Panel.kicad_sch).

The current board is [hardware/alarm-panel/Alarm Panel.kicad_pcb](hardware/alarm-panel/Alarm%20Panel.kicad_pcb); use [tools/pcb/resize_board_for_rj45_notch.py](tools/pcb/resize_board_for_rj45_notch.py) to adjust its outline while preserving manual placements. It contains the 110 x 80 mm outline, mounting holes, RJ45 notch, connector row, ESP32/W5500 footprints, and preliminary routing. The high-current 12V/siren tracks are sized to 1.1 mm using the documented 1 oz copper and 10°C rise assumptions. The replacement case will be designed around the finalized PCB; see [docs/pcb/pcb-completion-checklist.md](docs/pcb/pcb-completion-checklist.md) for remaining electrical, ground-pour, and manufacturing checks.

## KiCad design hardware/alarm-panel/Alarm Panel.kicad_pcb

Parts:
C1: 680 uF / 16 V; CP_Radial_D8.0mm_P3.50mm
C2, C3: 470 uF / 10 V; CP_Radial_D6.3mm_P2.50mm
C4: 100 nF / 25 V; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5: 1 uF / 25 V; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: 1N5822 SCHOTTKY 3A 40V; D_DO-201AD_P5.08mm_Vertical_AnodeUp
D2: 1N5822 flyback; D_DO-201AD_P5.08mm_Vertical_AnodeUp
F1: 2A TIME-DELAY 5x20mm; FuseHolder_Body24x10_P23.6mm
J1: DC_BARREL_JACK; BarrelJack_Horizontal
J2: Z1_GND_Z2; TerminalBlock_1x03_P2.54mm_Body8.15x6.40mm
J3: Z3_GND_Z4; TerminalBlock_1x03_P2.54mm_Body8.15x6.40mm
J4: Z5_GND_Z6; TerminalBlock_1x03_P2.54mm_Body8.15x6.40mm
J5: Z7_GND_Z8; TerminalBlock_1x03_P2.54mm_Body8.15x6.40mm
J6: Z9_GND_Z10; TerminalBlock_1x03_P2.54mm_Body8.15x6.40mm
J7: SPARE_NC_GND_NC; TerminalBlock_1x03_P2.54mm_Body8.15x6.40mm
J8: PWR_MODULE; PowerModule_1x05_P2.54mm_Body15x20mm
J9: ESP32_OLED; ESP32_OLED_2x15_P2.54mm_Row27.94mm
J10: W5500; W5500_2x5_P2.54mm_Module55.1x28.1mm
J11, J12: AUX_12V_GND; TerminalBlock_1x02_P2.54mm_Body5.60x6.40mm
J13: SIREN_OUT; TerminalBlock_1x02_P2.54mm_Body5.60x6.40mm
Q1: IRFZ44N; TO-220-3_Vertical
R1, R2, R3, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 10 ohm gate resistor; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 10k Q1 gate pulldown; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 10k driver input pulldown; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: TC4420CPA; DIP-8_W7.62mm

Connections:
3V3: C3.1, J9.29, J10.10, R1.1, R2.1, R3.1, R4.1
5V: C2.1, J8.5, J9.30, J10.9
12V: C1.1, C4.1, C5.1, D1.1 (K), D2.1 (K), J8.2, J11.1, J12.1, J13.1, U1.1 (VDD), U1.8 (VDD)
12V_IN: F1.1, J1.1
ARM_LED: J9.14
FUSED_12V: D1.2 (A), F1.2
GATE_DRIVER_OUT: R5.1, U1.6 (OUTPUT), U1.7 (OUTPUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.2, J1.3, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2 (Pin_2_2), J8.3, J8.4, J9.27, J9.28, J10.7, J11.2, J12.2, Q1.3 (S), R6.2, R7.2, U1.4 (GND), U1.5 (GND)
MISO: J9.18, J10.8
MOSI: J9.16, J10.6
OLED_SCL: J9.3
OLED_SDA: J9.9
Q1_GATE: Q1.1 (G), R5.2, R6.1
SCLK: J9.26, J10.2
SCS: J9.20, J10.4
SIREN_DRAIN: D2.2 (A), J13.2, Q1.2 (D)
SIREN_GATE: J9.12, R7.1, U1.2 (INPUT)
Z1: J2.1, J9.10, R1.2
Z2: J2.3, J9.8, R2.2
Z3: J3.1, J9.6, R3.2
Z4: J3.3, J9.4, R4.2
Z5: J4.1, J9.21
Z6: J4.3, J9.19
Z7: J5.1, J9.17
Z8: J5.3, J9.13
Z9: J6.1, J9.11
Z10: J6.3, J9.1

Board: 2 copper layers, 110.0 x 80.0 mm, 34 parts (0 on the bottom side), 24 nets.

Other parts of the board:
H1, H2, H3, H4: 2.0 mm NPTH; MountingHole_NPTH_2.0mm
